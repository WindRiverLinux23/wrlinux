# it sets 'nftables' as default firewall in meta-networking
# reset to 'iptables' for backward compatible in wrlinux
NETWORKMANAGER_FIREWALL_DEFAULT = "iptables"
